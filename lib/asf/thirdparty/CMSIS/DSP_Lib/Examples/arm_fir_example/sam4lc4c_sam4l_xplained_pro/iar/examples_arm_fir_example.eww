<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_arm_fir_example_flash.ewp</path>
	</project>
</workspace>
