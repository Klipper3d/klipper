<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_arm_graphic_equalizer_example_flash.ewp</path>
	</project>
</workspace>
