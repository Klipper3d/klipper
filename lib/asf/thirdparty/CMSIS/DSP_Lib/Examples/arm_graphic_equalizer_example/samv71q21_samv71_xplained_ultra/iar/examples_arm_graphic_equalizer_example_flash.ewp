# IAR project examples_arm_graphic_equalizer_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21B__; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/cmsis/samv71/source/templates; ..; ../../../../../../../sam/boards/samv71_xplained_ultra; ../..; ../../../../../../../sam/boards; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../common/services/clock; ../../../../../../../sam/utils/fpu; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/mpu; ../../../../../../../common/utils; ../../../../../../../common/services/gpio; ../../../../../../../sam/utils; ../../../../../../../sam/utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_graphic_equalizer_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_graphic_equalizer_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../../sam/utils/cmsis/samv71/include/: samv71n20.h samv71q19.h samv71j20.h samv71j21b.h samv71n19.h samv71q19b.h samv71j19.h samv71q20.h samv71n19b.h samv71n21b.h samv71n20b.h samv71q21b.h samv71j19b.h samv71.h samv71q21.h samv71q20b.h samv71j21.h samv71n21.h samv71j20b.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../../sam/utils/cmsis/samv71/include/component/: gpbr.h qspi.h rswdt.h efc.h hsmci.h utmi.h usbhs.h pio.h mlb.h icm.h aes.h rtc.h twihs.h matrix.h ssc.h usart.h xdmac.h i2sc.h afec.h mcan.h uart.h tc.h pwm.h rtt.h trng.h wdt.h dacc.h sdramc.h gmac.h chipid.h acc.h isi.h pmc.h rstc.h spi.h supc.h smc.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../../sam/utils/cmsis/samv71/include/instance/: spi0.h gmac.h efc.h uart3.h twihs2.h hsmci.h rswdt.h usart2.h usart0.h pwm0.h smc.h rstc.h mcan1.h afec1.h qspi.h trng.h utmi.h acc.h spi1.h dacc.h tc2.h sdramc.h rtc.h pwm1.h twihs1.h afec0.h usbhs.h mcan0.h pmc.h rtt.h matrix.h uart4.h pioa.h icm.h tc1.h gpbr.h piob.h i2sc1.h uart1.h piod.h twihs0.h aes.h wdt.h uart0.h chipid.h tc3.h mlb.h xdmac.h ssc.h isi.h tc0.h usart1.h pioc.h uart2.h i2sc0.h pioe.h supc.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../../sam/utils/cmsis/samv71/include/pio/: samv71q21b.h samv71n20b.h samv71q21.h samv71j20.h samv71j21b.h samv71q19b.h samv71j19.h samv71j21.h samv71q20b.h samv71n19b.h samv71n21.h samv71n20.h samv71j19b.h samv71n21b.h samv71n19.h samv71q19.h samv71q20.h samv71j20b.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../../../sam/boards/samv71_xplained_ultra/: init.c led.h samv71_xplained_ultra.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/mpu
    ../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example
    ../../: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c math_helper.c math_helper.h documentation.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/samv71q21_samv71_xplained_ultra
    ../: conf_clock.h conf_board.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/samv71
    ../../../../../../../common/services/clock/samv71/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
