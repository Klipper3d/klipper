<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_arm_signal_converge_example_flash.ewp</path>
	</project>
</workspace>
