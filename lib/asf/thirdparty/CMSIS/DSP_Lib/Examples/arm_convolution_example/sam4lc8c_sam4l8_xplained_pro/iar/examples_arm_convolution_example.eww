<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_arm_convolution_example_flash.ewp</path>
	</project>
</workspace>
