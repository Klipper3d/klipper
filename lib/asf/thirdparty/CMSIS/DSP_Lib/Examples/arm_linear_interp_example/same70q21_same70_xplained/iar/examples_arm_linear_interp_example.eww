<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_arm_linear_interp_example_flash.ewp</path>
	</project>
</workspace>
