<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_arm_matrix_example_flash.ewp</path>
	</project>
</workspace>
