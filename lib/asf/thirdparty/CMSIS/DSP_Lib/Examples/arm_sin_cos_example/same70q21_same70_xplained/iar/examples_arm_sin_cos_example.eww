<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_arm_sin_cos_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\examples_arm_sin_cos_example_sram.ewp</path>
	</project>
</workspace>
