/* ANSI-C code produced by gperf version 3.1 */
/* Command-line: gperf -l -e'	' out/gcode_parser.keywords.gperf  */
/* Computed positions: -k'1,3' */

#if !((' ' == 32) && ('!' == 33) && ('"' == 34) && ('#' == 35) \
      && ('%' == 37) && ('&' == 38) && ('\'' == 39) && ('(' == 40) \
      && (')' == 41) && ('*' == 42) && ('+' == 43) && (',' == 44) \
      && ('-' == 45) && ('.' == 46) && ('/' == 47) && ('0' == 48) \
      && ('1' == 49) && ('2' == 50) && ('3' == 51) && ('4' == 52) \
      && ('5' == 53) && ('6' == 54) && ('7' == 55) && ('8' == 56) \
      && ('9' == 57) && (':' == 58) && (';' == 59) && ('<' == 60) \
      && ('=' == 61) && ('>' == 62) && ('?' == 63) && ('A' == 65) \
      && ('B' == 66) && ('C' == 67) && ('D' == 68) && ('E' == 69) \
      && ('F' == 70) && ('G' == 71) && ('H' == 72) && ('I' == 73) \
      && ('J' == 74) && ('K' == 75) && ('L' == 76) && ('M' == 77) \
      && ('N' == 78) && ('O' == 79) && ('P' == 80) && ('Q' == 81) \
      && ('R' == 82) && ('S' == 83) && ('T' == 84) && ('U' == 85) \
      && ('V' == 86) && ('W' == 87) && ('X' == 88) && ('Y' == 89) \
      && ('Z' == 90) && ('[' == 91) && ('\\' == 92) && (']' == 93) \
      && ('^' == 94) && ('_' == 95) && ('a' == 97) && ('b' == 98) \
      && ('c' == 99) && ('d' == 100) && ('e' == 101) && ('f' == 102) \
      && ('g' == 103) && ('h' == 104) && ('i' == 105) && ('j' == 106) \
      && ('k' == 107) && ('l' == 108) && ('m' == 109) && ('n' == 110) \
      && ('o' == 111) && ('p' == 112) && ('q' == 113) && ('r' == 114) \
      && ('s' == 115) && ('t' == 116) && ('u' == 117) && ('v' == 118) \
      && ('w' == 119) && ('x' == 120) && ('y' == 121) && ('z' == 122) \
      && ('{' == 123) && ('|' == 124) && ('}' == 125) && ('~' == 126))
/* The character set is not based on ISO-646.  */
#error "gperf generated tables don't work with this execution character set. Please report a bug to <bug-gperf@gnu.org>."
#endif


#include <stdlib.h>
#include <string.h>
struct GCodeKeywordDetail { const char* name; int id; };

#define TOTAL_KEYWORDS 33
#define MIN_WORD_LENGTH 1
#define MAX_WORD_LENGTH 7
#define MIN_HASH_VALUE 1
#define MAX_HASH_VALUE 61
/* maximum key range = 61, duplicates = 0 */

#ifdef __GNUC__
__inline
#else
#ifdef __cplusplus
inline
#endif
#endif
static unsigned int
hash (register const char *str, register size_t len)
{
  static unsigned char asso_values[] =
    {
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 46, 62, 62,
      41, 36, 20, 60, 55, 50, 45, 40, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      15, 30, 10, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 35, 62, 30, 62, 62, 62, 15, 15, 62,
      10,  0, 15, 62, 62,  0, 62, 62,  0, 62,
       5,  5, 62, 62, 10, 10,  0,  0, 62, 62,
      62, 62, 62, 25, 62,  5,  0, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
      62, 62, 62, 62, 62, 62
    };
  register unsigned int hval = len;

  switch (hval)
    {
      default:
        hval += asso_values[(unsigned char)str[2]];
      /*FALLTHROUGH*/
      case 2:
      case 1:
        hval += asso_values[(unsigned char)str[0]];
        break;
    }
  return hval;
}

struct GCodeKeywordDetail *
gcode_keyword_lookup (register const char *str, register size_t len)
{
  static unsigned char lengthtable[] =
    {
       0,  1,  2,  3,  4,  0,  1,  2,  3,  0,  0,  1,  2,  3,
       4,  0,  1,  2,  3,  0,  5,  1,  2,  3,  0,  5,  1,  7,
       3,  0,  0,  1,  2,  0,  0,  0,  1,  1,  0,  0,  0,  1,
       1,  0,  0,  0,  1,  1,  0,  0,  0,  1,  0,  0,  0,  0,
       1,  0,  0,  0,  0,  1
    };
  static struct GCodeKeywordDetail wordlist[] =
    {
      {""},
      {"~",268},
      {"if",280},
      {"int",295},
      {"true",288},
      {""},
      {"}",293},
      {"or",265},
      {"not",279},
      {""}, {""},
      {">",276},
      {">=",278},
      {"nan",286},
      {"else",281},
      {""},
      {"<",275},
      {"<=",277},
      {"inf",287},
      {""},
      {"false",289},
      {"*",273},
      {"**",272},
      {"str",294},
      {""},
      {"float",296},
      {"{",292},
      {"boolean",297},
      {"and",266},
      {""}, {""},
      {"]",291},
      {"==",267},
      {""}, {""}, {""},
      {"[",290},
      {")",285},
      {""}, {""}, {""},
      {"/",274},
      {"(",284},
      {""}, {""}, {""},
      {".",282},
      {"%",271},
      {""}, {""}, {""},
      {"-",270},
      {""}, {""}, {""}, {""},
      {",",283},
      {""}, {""}, {""}, {""},
      {"+",269}
    };

  if (len <= MAX_WORD_LENGTH && len >= MIN_WORD_LENGTH)
    {
      register unsigned int key = hash (str, len);

      if (key <= MAX_HASH_VALUE)
        if (len == lengthtable[key])
          {
            register const char *s = wordlist[key].name;

            if (*str == *s && !memcmp (str + 1, s + 1, len - 1))
              return &wordlist[key];
          }
    }
  return 0;
}
